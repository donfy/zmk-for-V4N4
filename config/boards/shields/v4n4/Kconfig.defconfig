## config/boards/shields/v4n4/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_V4N4
    def_bool $(shields_list_contains,v4n4)
```
